DESCRIPTION = "The Openmoko Dialer"
DEPENDS += " libframeworkd-glib libnotify"
PV = "0.0.1+svnr${SRCDATE}"
PR = "r8"
PE = "1"

inherit openmoko-panel-plugin-shr
